# Keil uVision project ugfx_virtual_keyboard.uvprojx, settings and files
target STM32F469NI Flash (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ugfx_virtual_keyboard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;.\ugfx;.\ugfx\drivers\gdisp\STM32LTDC;.\ugfx\drivers\ginput\touch\FT6x06;.\STM32CubeF4\Drivers\BSP\STM32469I-Discovery;.\ugfx\3rdparty\fatfs-0.10b\src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group source
    ./: main.c gfxconf.h gui.c userfonts.h colors.h gfxconf_old.h gui.h maptilebmp.h romfs_files.h user_colors.h user_styles.h widgetstyles.h diskio.c tm_stm32_rtc.c trace.c tm_stm32_gps.c tm_stm32_usart.c tm_stm32_gpio.c tm_stm32_buffer.c tm_stm32_delay.c gps.c gmouse_lld_FT6x06_board.h tm_stm32_i2c.c
  group ugfx
    ./ugfx/src/: gfx_mk.c
    ./ugfx/drivers/gdisp/STM32LTDC/: gdisp_lld_STM32LTDC.c
    ./ugfx/drivers/ginput/touch/FT6x06/: gmouse_lld_FT6x06.c
  group STM32CubeF4
    ./STM32CubeF4/Drivers/BSP/Components/ft6x06/: ft6x06.c
    ./STM32CubeF4/Drivers/BSP/Components/otm8009a/: otm8009a.c
    ./STM32CubeF4/Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c stm32469i_discovery_sd.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:DMA2D 1.5.0, Device:STM32Cube HAL:DSI 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:I2C 1.5.0, Device:STM32Cube HAL:LTDC 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:RTC 1.5.0, Device:STM32Cube HAL:SD 1.5.0, Device:STM32Cube HAL:SDRAM 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:STM32Cube HAL:USART 1.5.0, Device:Startup 2.5.0
